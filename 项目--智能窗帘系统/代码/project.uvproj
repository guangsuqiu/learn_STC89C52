# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c define.h Delay.c Delay.h DS1302.c DS1302.h LCD1602.c LCD1602.h DS18B20.c DS18B20.h OneWire.c OneWire.h ADC0832.c ADC0832.h BUZZER.c BUZZER.h KEY.c KEY.h BULETOOTH.c BULETOOTH.h MOTOR.c MOTOR.h UART.c UART.h
