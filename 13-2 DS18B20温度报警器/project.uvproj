# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c OneWire.h DS18B20.c DS18B20.h LCD1602.c LCD1602.h OneWire.c key.h AT24C02.c AT24C02.h Delay.c Delay.h IIC.c IIC.h key.c Timer0.h Timer0.c
